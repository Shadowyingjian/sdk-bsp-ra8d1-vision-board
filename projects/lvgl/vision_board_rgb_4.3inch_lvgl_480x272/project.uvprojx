# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: libraries\components\LVGL-v9.1.0\src\osal;libraries\components\LVGL-v9.1.0\src\widgets\canvas;libraries\components\LVGL-v9.1.0\src\others\monkey;libraries\components\LVGL-v9.1.0\src\widgets\buttonmatrix;packages\gt911-latest\inc;libraries\components\LVGL-v9.1.0\src\widgets\tabview;libraries\components\LVGL-v9.1.0\src\themes\mono;libraries\components\LVGL-v9.1.0\src\others\file_explorer;libraries\HAL_Drivers\config;rt-thread\components\drivers\include;libraries\components\LVGL-v9.1.0\src\widgets\table;libraries\components\LVGL-v9.1.0\src\widgets\calendar;libraries\components\LVGL-v9.1.0\src\misc\cache;libraries\components\LVGL-v9.1.0\src\libs\bmp;libraries\components\LVGL-v9.1.0\src\widgets\line;rt-thread\components\finsh;libraries\components\LVGL-v9.1.0\src\widgets\win;libraries\components\LVGL-v9.1.0\src\libs\fsdrv;libraries\components\LVGL-v9.1.0\src\widgets\tileview;rt-thread\components\libc\posix\ipc;libraries\components\LVGL-v9.1.0\src\drivers\windows;libraries\components\LVGL-v9.1.0\src\others\gridnav;libraries\components\LVGL-v9.1.0\src\libs\rle;libraries\components\LVGL-v9.1.0\src\widgets\image;libraries\components\LVGL-v9.1.0\src\widgets\dropdown;libraries\components\LVGL-v9.1.0\src\widgets\bar;libraries\components\LVGL-v9.1.0\src\libs\lz4;libraries\components\LVGL-v9.1.0\src\draw\renesas\dave2d;board\lvgl\demo;libraries\components\LVGL-v9.1.0\src\libs\qrcode;libraries\components\LVGL-v9.1.0\src\drivers\display\st7735;libraries\components\LVGL-v9.1.0\src\widgets\label;libraries\components\LVGL-v9.1.0\src\widgets\checkbox;libraries\components\LVGL-v9.1.0\src\libs\libpng;board;rt-thread\components\libc\posix\io\epoll;libraries\components\LVGL-v9.1.0\src\stdlib\builtin;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\compilers\common\extension;libraries\components\LVGL-v9.1.0\src\others\snapshot;libraries\components\LVGL-v9.1.0\src\widgets\imagebutton;libraries\components\LVGL-v9.1.0\src\others\observer;libraries\components\LVGL-v9.1.0\src\drivers\display\st7789;libraries\components\LVGL-v9.1.0\src\widgets\roller;.;libraries\components\LVGL-v9.1.0\src\libs\barcode;libraries\components\LVGL-v9.1.0\src\draw\sw\blend\neon;libraries\components\LVGL-v9.1.0\src\drivers\display\lcd;libraries\components\LVGL-v9.1.0\src\widgets\msgbox;libraries\components\LVGL-v9.1.0\src\tick;libraries\components\LVGL-v9.1.0\src\libs\thorvg;libraries\components\LVGL-v9.1.0\src\libs\gif;libraries\components\LVGL-v9.1.0\src\drivers\display\drm;libraries\components\LVGL-v9.1.0\src\libs\libjpeg_turbo;libraries\components\LVGL-v9.1.0\src\drivers\sdl;libraries\components\LVGL-v9.1.0\src\widgets\led;libraries\components\LVGL-v9.1.0\src\widgets\scale;libraries\components\LVGL-v9.1.0\src\libs\bin_decoder;libraries\components\LVGL-v9.1.0\src\widgets\animimage;rt-thread\components\drivers\include;libraries\components\LVGL-v9.1.0\src\others\imgfont;libraries\components\LVGL-v9.1.0\src\draw\nxp\vglite;libraries\components\LVGL-v9.1.0\env_support\rt-thread;libraries\components\LVGL-v9.1.0\src\draw\sw\blend\arm2d;libraries\components\LVGL-v9.1.0\src\libs\tjpgd;libraries\components\LVGL-v9.1.0\src\layouts\grid;libraries\components\LVGL-v9.1.0\src\draw\nxp\pxp;libraries\components\LVGL-v9.1.0\src\themes\simple;libraries\components\LVGL-v9.1.0\src\drivers\nuttx;libraries\components\LVGL-v9.1.0\src\display;libraries\components\LVGL-v9.1.0\src;libraries\components\LVGL-v9.1.0\src\widgets\spinner;libraries\components\LVGL-v9.1.0\src\others\sysmon;libraries\components\LVGL-v9.1.0\src\widgets\spinbox;board\lvgl;rt-thread\libcpu\arm\common;libraries\components\LVGL-v9.1.0\src\libs\ffmpeg;board\ports;libraries\components\LVGL-v9.1.0\src\stdlib;rt-thread\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\touch;libraries\components\LVGL-v9.1.0\src\drivers\libinput;libraries\components\LVGL-v9.1.0\src\libs\freetype;libraries\components\LVGL-v9.1.0\src\drivers\display\st7796;libraries\components\LVGL-v9.1.0\src\draw\sw;libraries\components\LVGL-v9.1.0\src\layouts\flex;libraries\components\LVGL-v9.1.0\src\themes\default;libraries\HAL_Drivers;libraries\components\LVGL-v9.1.0\src\draw\sw\blend;rt-thread\components\libc\posix\io\eventfd;libraries\components\LVGL-v9.1.0\src\others\ime;libraries\components\LVGL-v9.1.0\src\draw;libraries\components\LVGL-v9.1.0\src\layouts;libraries\components\LVGL-v9.1.0\src\libs\rlottie;libraries\components\LVGL-v9.1.0\src\widgets\slider;libraries\components\LVGL-v9.1.0\src\indev;libraries\components\LVGL-v9.1.0\src\widgets\textarea;libraries\components\LVGL-v9.1.0\src\themes;libraries\components\LVGL-v9.1.0\src\widgets\list;libraries\components\LVGL-v9.1.0\src\widgets\button;rt-thread\libcpu\arm\cortex-m85;libraries\components\LVGL-v9.1.0\src\draw\vg_lite;libraries\components\LVGL-v9.1.0\src\others\fragment;libraries\components\LVGL-v9.1.0\src\drivers;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\components\LVGL-v9.1.0\src\draw\sw\arm2d;libraries\components\LVGL-v9.1.0\src\widgets\objx_templ;libraries\components\LVGL-v9.1.0\src\drivers\x11;libraries\components\LVGL-v9.1.0\src\misc;libraries\components\LVGL-v9.1.0\src\drivers\display\fb;libraries\components\LVGL-v9.1.0\src\widgets\chart;libraries\components\LVGL-v9.1.0\src\widgets\arc;libraries\components\LVGL-v9.1.0\src\font;libraries\components\LVGL-v9.1.0\src\draw\sdl;libraries\components\LVGL-v9.1.0\src\others\vg_lite_tvg;rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\components\LVGL-v9.1.0\src\core;libraries\components\LVGL-v9.1.0\src\widgets\keyboard;rt-thread\components\drivers\include;libraries\components\LVGL-v9.1.0\src\drivers\display\tft_espi;libraries\components\LVGL-v9.1.0\src\libs\lodepng;libraries\components\LVGL-v9.1.0\src\widgets\menu;libraries\components\LVGL-v9.1.0\src\libs\tiny_ttf;libraries\components\LVGL-v9.1.0\src\draw\sw\blend\helium;libraries\components\LVGL-v9.1.0\src\drivers\evdev;libraries\components\LVGL-v9.1.0\src\widgets\span;libraries\components\LVGL-v9.1.0\src\widgets\switch;libraries\components\LVGL-v9.1.0\src\drivers\display\ili9341
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group gt911
    packages/gt911-latest/src/: gt911.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group LVGL
    libraries/components/LVGL-v9.1.0/src/draw/nxp/vglite/: lv_vglite_buf.c lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_label.c lv_vglite_matrix.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_line.c lv_draw_vglite_layer.c lv_draw_vglite_img.c lv_draw_vglite_triangle.c lv_vglite_path.c lv_vglite_utils.c
    libraries/components/LVGL-v9.1.0/src/libs/libpng/: lv_libpng.c
    libraries/components/LVGL-v9.1.0/src/font/: lv_font_montserrat_38.c lv_font_unscii_8.c lv_font_montserrat_36.c lv_font_montserrat_48.c lv_font_montserrat_40.c lv_font_montserrat_28.c lv_binfont_loader.c lv_font.c lv_font_montserrat_10.c lv_font_unscii_16.c lv_font_fmt_txt.c lv_font_montserrat_14.c lv_font_simsun_16_cjk.c lv_font_montserrat_46.c lv_font_montserrat_28_compressed.c lv_font_montserrat_12.c lv_font_montserrat_30.c lv_font_montserrat_16.c lv_font_montserrat_24.c lv_font_montserrat_32.c lv_font_montserrat_18.c lv_font_montserrat_34.c lv_font_montserrat_20.c lv_font_montserrat_42.c lv_font_montserrat_22.c lv_font_montserrat_44.c lv_font_montserrat_8.c lv_font_montserrat_26.c lv_font_dejavu_16_persian_hebrew.c
    libraries/components/LVGL-v9.1.0/src/widgets/canvas/: lv_canvas.c
    libraries/components/LVGL-v9.1.0/src/misc/: lv_style.c lv_anim.c lv_style_gen.c lv_color.c lv_async.c lv_anim_timeline.c lv_lru.c lv_fs.c lv_bidi.c lv_area.c lv_timer.c lv_event.c lv_math.c lv_profiler_builtin.c lv_rb.c lv_array.c lv_color_op.c lv_ll.c lv_text_ap.c lv_templ.c lv_utils.c lv_palette.c lv_log.c lv_text.c
    libraries/components/LVGL-v9.1.0/src/widgets/roller/: lv_roller.c
    libraries/components/LVGL-v9.1.0/src/draw/sw/: lv_draw_sw_box_shadow.c lv_draw_sw_transform.c lv_draw_sw_vector.c lv_draw_sw_gradient.c lv_draw_sw.c lv_draw_sw_fill.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_arc.c lv_draw_sw_letter.c lv_draw_sw_border.c lv_draw_sw_mask_rect.c lv_draw_sw_triangle.c lv_draw_sw_img.c
    libraries/components/LVGL-v9.1.0/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_lcd.c lv_nuttx_image_cache.c lv_nuttx_libuv.c lv_nuttx_fbdev.c lv_nuttx_entry.c lv_nuttx_touchscreen.c lv_nuttx_profiler.c
    libraries/components/LVGL-v9.1.0/src/draw/nxp/pxp/: lv_pxp_utils.c lv_draw_pxp_img.c lv_draw_buf_pxp.c lv_pxp_cfg.c lv_draw_pxp_fill.c lv_draw_pxp.c lv_draw_pxp_layer.c lv_pxp_osa.c
    libraries/components/LVGL-v9.1.0/src/libs/freetype/: lv_ftsystem.c lv_freetype_image.c lv_freetype_outline.c lv_freetype.c lv_freetype_glyph.c
    libraries/components/LVGL-v9.1.0/src/indev/: lv_indev.c lv_indev_scroll.c
    libraries/components/LVGL-v9.1.0/src/widgets/imagebutton/: lv_imagebutton.c
    libraries/components/LVGL-v9.1.0/src/widgets/table/: lv_table.c
    libraries/components/LVGL-v9.1.0/src/draw/vg_lite/: lv_draw_vg_lite_fill.c lv_draw_buf_vg_lite.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_draw_vg_lite_img.c lv_draw_vg_lite_line.c lv_vg_lite_pending.c lv_vg_lite_math.c lv_vg_lite_path.c lv_draw_vg_lite_label.c lv_draw_vg_lite_border.c lv_draw_vg_lite_triangle.c lv_vg_lite_utils.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_vector.c lv_draw_vg_lite.c
    libraries/components/LVGL-v9.1.0/src/drivers/display/st7796/: lv_st7796.c
    libraries/components/LVGL-v9.1.0/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    libraries/components/LVGL-v9.1.0/src/stdlib/clib/: lv_mem_core_clib.c lv_string_clib.c lv_sprintf_clib.c
    libraries/components/LVGL-v9.1.0/src/libs/rlottie/: lv_rlottie.c
    libraries/components/LVGL-v9.1.0/src/others/monkey/: lv_monkey.c
    libraries/components/LVGL-v9.1.0/src/widgets/led/: lv_led.c
    libraries/components/LVGL-v9.1.0/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    libraries/components/LVGL-v9.1.0/src/display/: lv_display.c
    libraries/components/LVGL-v9.1.0/src/others/file_explorer/: lv_file_explorer.c
    libraries/components/LVGL-v9.1.0/src/osal/: lv_pthread.c lv_rtthread.c lv_os_none.c lv_freertos.c lv_windows.c lv_cmsis_rtos2.c
    libraries/components/LVGL-v9.1.0/src/themes/simple/: lv_theme_simple.c
    libraries/components/LVGL-v9.1.0/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb565.c
    libraries/components/LVGL-v9.1.0/src/others/ime/: lv_ime_pinyin.c
    libraries/components/LVGL-v9.1.0/src/widgets/list/: lv_list.c
    libraries/components/LVGL-v9.1.0/src/drivers/sdl/: lv_sdl_mousewheel.c lv_sdl_keyboard.c lv_sdl_window.c lv_sdl_mouse.c
    libraries/components/LVGL-v9.1.0/src/layouts/flex/: lv_flex.c
    libraries/components/LVGL-v9.1.0/src/misc/cache/: lv_cache.c lv_image_cache.c lv_cache_entry.c _lv_cache_lru_rb.c
    libraries/components/LVGL-v9.1.0/src/themes/default/: lv_theme_default.c
    libraries/components/LVGL-v9.1.0/src/widgets/span/: lv_span.c
    libraries/components/LVGL-v9.1.0/src/libs/qrcode/: qrcodegen.c lv_qrcode.c
    libraries/components/LVGL-v9.1.0/src/: lv_init.c
    libraries/components/LVGL-v9.1.0/src/draw/: lv_draw.c lv_draw_image.c lv_draw_arc.c lv_draw_buf.c lv_draw_label.c lv_draw_mask.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    libraries/components/LVGL-v9.1.0/src/others/observer/: lv_observer.c
    libraries/components/LVGL-v9.1.0/src/drivers/display/ili9341/: lv_ili9341.c
    libraries/components/LVGL-v9.1.0/src/libs/fsdrv/: lv_fs_memfs.c lv_fs_fatfs.c lv_fs_cbfs.c lv_fs_stdio.c lv_fs_littlefs.c lv_fs_win32.c lv_fs_posix.c
    libraries/components/LVGL-v9.1.0/src/widgets/image/: lv_image.c
    libraries/components/LVGL-v9.1.0/src/widgets/tabview/: lv_tabview.c
    libraries/components/LVGL-v9.1.0/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    libraries/components/LVGL-v9.1.0/src/core/: lv_obj.c lv_obj_pos.c lv_obj_class.c lv_obj_draw.c lv_obj_tree.c lv_obj_property.c lv_obj_style_gen.c lv_obj_style.c lv_obj_event.c lv_refr.c lv_group.c lv_obj_id_builtin.c lv_obj_scroll.c
    libraries/components/LVGL-v9.1.0/src/widgets/label/: lv_label.c
    libraries/components/LVGL-v9.1.0/src/draw/sdl/: lv_draw_sdl.c
    libraries/components/LVGL-v9.1.0/src/widgets/tileview/: lv_tileview.c
    libraries/components/LVGL-v9.1.0/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    libraries/components/LVGL-v9.1.0/src/libs/ffmpeg/: lv_ffmpeg.c
    libraries/components/LVGL-v9.1.0/src/libs/gif/: lv_gif.c gifdec.c
    libraries/components/LVGL-v9.1.0/src/others/fragment/: lv_fragment_manager.c lv_fragment.c
    libraries/components/LVGL-v9.1.0/src/widgets/win/: lv_win.c
    libraries/components/LVGL-v9.1.0/src/stdlib/: lv_mem.c
    libraries/components/LVGL-v9.1.0/src/drivers/evdev/: lv_evdev.c
    libraries/components/LVGL-v9.1.0/src/others/vg_lite_tvg/: vg_lite_matrix.c
    libraries/components/LVGL-v9.1.0/src/stdlib/rtthread/: lv_string_rtthread.c lv_mem_core_rtthread.c lv_sprintf_rtthread.c
    libraries/components/LVGL-v9.1.0/src/layouts/grid/: lv_grid.c
    libraries/components/LVGL-v9.1.0/src/widgets/line/: lv_line.c
    libraries/components/LVGL-v9.1.0/src/libs/rle/: lv_rle.c
    libraries/components/LVGL-v9.1.0/src/widgets/calendar/: lv_calendar.c lv_calendar_header_dropdown.c lv_calendar_header_arrow.c
    libraries/components/LVGL-v9.1.0/src/libs/barcode/: lv_barcode.c code128.c
    libraries/components/LVGL-v9.1.0/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    libraries/components/LVGL-v9.1.0/src/others/gridnav/: lv_gridnav.c
    libraries/components/LVGL-v9.1.0/src/libs/tiny_ttf/: lv_tiny_ttf.c
    libraries/components/LVGL-v9.1.0/src/widgets/checkbox/: lv_checkbox.c
    libraries/components/LVGL-v9.1.0/src/widgets/spinbox/: lv_spinbox.c
    libraries/components/LVGL-v9.1.0/src/libs/bin_decoder/: lv_bin_decoder.c
    libraries/components/LVGL-v9.1.0/src/drivers/display/fb/: lv_linux_fbdev.c
    libraries/components/LVGL-v9.1.0/src/libs/bmp/: lv_bmp.c
    libraries/components/LVGL-v9.1.0/src/others/snapshot/: lv_snapshot.c
    libraries/components/LVGL-v9.1.0/src/widgets/animimage/: lv_animimage.c
    libraries/components/LVGL-v9.1.0/src/widgets/scale/: lv_scale.c
    libraries/components/LVGL-v9.1.0/src/drivers/display/drm/: lv_linux_drm.c
    libraries/components/LVGL-v9.1.0/src/others/imgfont/: lv_imgfont.c
    libraries/components/LVGL-v9.1.0/src/widgets/menu/: lv_menu.c
    libraries/components/LVGL-v9.1.0/src/widgets/msgbox/: lv_msgbox.c
    libraries/components/LVGL-v9.1.0/src/themes/: lv_theme.c
    libraries/components/LVGL-v9.1.0/src/widgets/textarea/: lv_textarea.c
    libraries/components/LVGL-v9.1.0/src/others/sysmon/: lv_sysmon.c
    libraries/components/LVGL-v9.1.0/src/widgets/dropdown/: lv_dropdown.c
    libraries/components/LVGL-v9.1.0/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    libraries/components/LVGL-v9.1.0/src/widgets/chart/: lv_chart.c
    libraries/components/LVGL-v9.1.0/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    libraries/components/LVGL-v9.1.0/src/libs/lz4/: lz4.c
    libraries/components/LVGL-v9.1.0/src/widgets/keyboard/: lv_keyboard.c
    libraries/components/LVGL-v9.1.0/src/widgets/spinner/: lv_spinner.c
    libraries/components/LVGL-v9.1.0/src/tick/: lv_tick.c
    libraries/components/LVGL-v9.1.0/src/widgets/switch/: lv_switch.c
    libraries/components/LVGL-v9.1.0/src/drivers/display/st7735/: lv_st7735.c
    libraries/components/LVGL-v9.1.0/src/widgets/button/: lv_button.c
    libraries/components/LVGL-v9.1.0/src/libs/lodepng/: lodepng.c lv_lodepng.c
    libraries/components/LVGL-v9.1.0/src/stdlib/micropython/: lv_mem_core_micropython.c
    libraries/components/LVGL-v9.1.0/src/widgets/arc/: lv_arc.c
    libraries/components/LVGL-v9.1.0/src/widgets/objx_templ/: lv_objx_templ.c
    libraries/components/LVGL-v9.1.0/src/drivers/display/st7789/: lv_st7789.c
    libraries/components/LVGL-v9.1.0/src/widgets/slider/: lv_slider.c
    libraries/components/LVGL-v9.1.0/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    libraries/components/LVGL-v9.1.0/src/themes/mono/: lv_theme_mono.c
    libraries/components/LVGL-v9.1.0/src/widgets/bar/: lv_bar.c
    libraries/components/LVGL-v9.1.0/src/layouts/: lv_layout.c
    libraries/components/LVGL-v9.1.0/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group LVGL-demo
    board/lvgl/demo/: lv_demo.c
    board/lvgl/demo/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    board/lvgl/demo/widgets/: lv_demo_widgets.c
    packages/lv_music_demo-latest/assets/: img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_wave_top.c
    packages/lv_music_demo-latest/: lv_demo_rtt_music.c lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c
  group LVGL-port
    board/lvgl/: lv_port_disp.c lv_port_indev.c
    libraries/components/LVGL-v9.1.0/env_support/rt-thread/: lv_rt_thread_port.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
